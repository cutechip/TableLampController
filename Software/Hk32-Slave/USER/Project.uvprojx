# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F0301MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HK32F030M,HK32F030MF4P6
  c include: ..\Libraries\HK32F030M_Lib\inc;..\Libraries\CMSIS\CM0\Core;..\Libraries\CMSIS\CM0;..\Libraries\HK32F030M_Lib\inc;..\Libraries\CMSIS\HK32F030M\Include;..\application;..\board;..\Util;..\USER;..\drives
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group application
    ../application/: system_process.c
  group user
    ./: hk32f030m_it.c main.c
  group drives
    ../drives/: drv_adc.c drv_gpio.c drv_systick.c drv_usart.c drv_pwm.c
  group board
    ../board/: sys_power.c charge_detection.c modulator.c
  group hwlib
    ../Libraries/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_awu.c hk32f030m_beep.c hk32f030m_crc.c hk32f030m_dbgmcu.c hk32f030m_exti.c hk32f030m_flash.c hk32f030m_gpio.c hk32f030m_i2c.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_pwr.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c hk32f030m_wwdg.c
  group core
    ../Libraries/CMSIS/HK32F030M/Source/: KEIL_Startup_hk32f030m.s system_hk32f030m.c
  group utils
    ../Util/: sys_blink.c sys_keyinput.c sys_ringbuffer.c sys_task.c sys_time.c
